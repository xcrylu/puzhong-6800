# Keil uVision project test.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: test +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\src;.\src\lib;.\src\include
  group Source Group 1
    ./src/lib/: common.c uart.c ds1302.c
