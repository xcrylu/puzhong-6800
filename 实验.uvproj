# Keil uVision project 实验.uvproj, settings and files
target Target_1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 实验 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src;.\src\lib;.\src\include
  group Source Group 1
    ./: README.txt
    ./src/lib/: keyScan.c common.c
